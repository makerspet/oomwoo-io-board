# Repository makerspet/oomwoo-io-board (continued)

## KiCad design kicad/main/Main.kicad_pcb (continued)

Schematic: Battery-Charger.kicad_sch

Parts:
BAT2: BATTERY; 436500412; Manufacturer Part 436500412; LCSC C563847
C47, C58: 330pF/25V; C_0603_1608Metric
C59, C61, C64, C65, C73: 100nF/50V; C_0603_1608Metric; LCSC C1591
C60, C66, C67, C68, C69, C70, C71, C72, C74, C76, C78, C80, C81, C82, C83, C94, C96, C97, C98, C99, C100: 10uF/25V; C_0603_1608Metric; LCSC C96446
C75, C79: 47nF/50V; C_0603_1608Metric
C77, C125, C126: 1nF/50V; C_0603_1608Metric
CN2: EV2400; A2543WV-4P; Manufacturer Part A2543WV-4P; LCSC C239364; not fitted
CONTACT_CHGR1: WAFER-PH2_0-4PWB; Manufacturer Part WAFER-PH2.0-4PWB; LCSC C3029442
D1, D2: TVS2200DRVR; Manufacturer Part TVS2200DRVR; LCSC C523793
D3: SMAJ18A_C148219; Manufacturer Part SMAJ18A; LCSC C148219
D29: 3V3-STAT; LED0603-B; VOLTAGERATE *; MANUFACTURINGPARTNUMBER *; LCSC C19171394
D34: TPD2EUSB30DRTR; SOTFL35P100X50-3N; MPN TPD2EUSB30DRTR; LCSC C97502
D39, D40: BZT52C12T-7; Manufacturer Part BZT52C12T-7; LCSC C507911
IC5: TPS25730DREFR; Manufacturer_Part_Number TPS25730DREFR; Mouser Part Number 595-TPS25730DREFR
L7: 1uH; GSM0420-1R0-M; Manufacturer Part GSM0420-1R0-M; LCSC C51933819
Q4, Q21: SQJ844AEP-T1_GE3; Manufacturer Part SQJ844AEP-T1_GE3; LCSC C727613
R37: 1k; R_0603_1608Metric; VOLTAGERATE *; MANUFACTURINGPARTNUMBER *
R60: 30.31k; R_0603_1608Metric
R75, R76, R100: 100; R_0805_2012Metric
R99: 215k; R_0603_1608Metric; Manufacturer Part RC0402FR-07215KL; LCSC C185443
R115, R128, R130, R133, R138, R139: 100k; R_0603_1608Metric
R127, R136, R137: 5.24k; R_0603_1608Metric
R129: 17.4k; R_0603_1608Metric; Manufacturer Part RC0402FR-0717K4L; LCSC C327366
R131: 20k; R_0603_1608Metric
R132: 10k; R_0603_1608Metric
R140: 1k; R_0603_1608Metric
U7: BQ25792RQMR; Manufacturer Part BQ25792RQMR; LCSC C2862876
USB2: USB4215-03-A_REVA; GCT_USB4215-03-A_REVA; MPN USB4215-03-A; LCSC C37616412

Connections:
/BATTERY-CHARGER/ADCIN1: IC5.2 (ADCIN1), R139.2, R140.1
/BATTERY-CHARGER/ADCIN2: IC5.3 (ADCIN2), R137.2, R138.1
/BATTERY-CHARGER/ADCIN3: IC5.5 (ADCIN3), R133.2, R136.1
/BATTERY-CHARGER/ADCIN4: IC5.7 (ADCIN4), R130.2, R131.1
/BATTERY-CHARGER/CC1: C47.2, IC5.28 (CC1), USB2.A5 (CC1)
/BATTERY-CHARGER/CC2: C58.2, IC5.29 (CC2), USB2.B5 (CC2)
/BATTERY-CHARGER/D+: D34.1 (D+), USB2.A6 (DP1), USB2.B6 (DP2); also elsewhere on the board
/BATTERY-CHARGER/D-: D34.2 (D-), USB2.A7 (DN1), USB2.B7 (DN2); also elsewhere on the board
/BATTERY-CHARGER/DRAIN: IC5.15 (DRAIN_1), IC5.30 (DRAIN_2), IC5.40 (DRAIN_3)
/BATTERY-CHARGER/ID: BAT2.3; also elsewhere on the board
/BATTERY-CHARGER/LDO3V3: C74.2, IC5.1 (LDO_3V3), R128.1, R130.1, R133.1, R137.1, R139.1
/BATTERY-CHARGER/NTC: BAT2.2, R60.2, R127.2, U7.16 (TS)
/BATTERY-CHARGER/P+/C+: BAT2.1, R100.2, U7.22 (BAT), U7.23 (BAT)
/BATTERY-CHARGER/REGN: C70.2, D29.1, R115.2, R127.1, U7.5 (REGN)
/BATTERY-CHARGER/SCL: CN2.2, IC5.9 (I2CT_SCL), U7.14 (SCL); also elsewhere on the board
/BATTERY-CHARGER/SDA: CN2.3, IC5.8 (I2CT_SDA), U7.15 (SDA); also elsewhere on the board
/BATTERY-CHARGER/VBUS: C61.2, C64.2, C65.2, C66.2, D2.4 (IN), D2.5 (IN), D2.6 (IN), IC5.23 (VBUS_IN_1), IC5.24 (VBUS_IN_2), IC5.25 (VBUS_IN_3), IC5.32 (VBUS_1), IC5.33 (VBUS_2), IC5.42 (VBUS_IN_4), IC5.43 (VBUS_3), USB2.A4_B9 (VBUS_A), USB2.B4_A9 (VBUS_B)
/BATTERY-CHARGER/VOUT_PD: C60.1, C71.2, C72.2, C73.2, IC5.20 (PPHV_1), IC5.21 (PPHV_2), IC5.22 (PPHV_3), IC5.41 (PPHV_4), Q21.6 (D1), U7.9 (VAC1)
/BATTERY-CHARGER/~INT: R132.1, U7.21 (INT#); also elsewhere on the board
BAT-VCC: C83.1, C96.2, C97.2, C98.2, C99.2, C100.2, D3.1, U7.25 (SYS); also elsewhere on the board
GND: BAT2.4, BAT2.5, BAT2.6, C47.1, C58.1, C59.1, C60.2, C61.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.2, C70.1, C71.1, C72.1, C73.1, C74.1, C76.1, C77.1, C78.2, C80.1, C81.1, C82.1, C83.2, C94.2, C96.1, C97.1, C98.1, C99.1, C100.1, CN2.1, CONTACT_CHGR1.1, CONTACT_CHGR1.2, CONTACT_CHGR1.5, CONTACT_CHGR1.6, D1.1 (GND), D1.2 (GND), D1.3 (GND), D1.7 (GND), D2.1 (GND), D2.2 (GND), D2.3 (GND), D2.7 (GND), D3.2, D34.3 (GND), IC5.11 (GND_1), IC5.12 (GND_2), IC5.14 (GND_3), IC5.16 (GND_4), IC5.17 (GND_5), IC5.31 (GND_6), IC5.34 (GND_7), IC5.35 (GND_8), IC5.39 (GND_9), IC5.44 (GND_10), R60.1, R99.1, R129.1, R131.2, R136.2, R138.2, R140.2, U7.13 (CE#), U7.27 (GND), USB2.A1_B12 (GND_A), USB2.B1_A12 (GND_B), USB2.SH1 (SHIELD), USB2.SH2 (SHIELD__1), USB2.SH3 (SHIELD__2), USB2.SH4 (SHIELD__3); also elsewhere on the board
unnamed: D29.2, R37.2
unnamed: C125.1, D39.2 (A), Q4.1 (S1), Q4.3 (S2)
unnamed: C125.2, D39.1 (K), Q4.2 (G1), Q4.4 (G2), R75.1
unnamed: C126.1, D40.2 (A), Q21.1 (S1), Q21.3 (S2)
unnamed: C126.2, D40.1 (K), Q21.2 (G1), Q21.4 (G2), R76.1
unnamed: C76.2, IC5.4 (LDO_1V5)
unnamed: IC5.18 (~FAULT_IN), R128.2
unnamed: C94.1, CONTACT_CHGR1.3, CONTACT_CHGR1.4, D1.4 (IN), D1.5 (IN), D1.6 (IN), Q4.5 (D2), U7.8 (VAC2)
unnamed: R76.2, U7.11 (ACDRV1)
unnamed: R75.2, U7.10 (ACDRV2)
unnamed: R100.1, U7.18 (BATP)
unnamed: C75.1, U7.4 (BTST1)
unnamed: C79.1, U7.19 (BTST2)
unnamed: R99.2, R115.1, U7.17 (ILIM_HIZ)
unnamed: C78.1, C80.2, C81.2, C82.2, U7.29 (PMID)
unnamed: R129.2, U7.20 (PROG)
unnamed: C77.2, U7.24 (SDRV)
unnamed: R37.1, U7.1 (STAT)
unnamed: C75.2, L7.1, U7.28 (SW1)
unnamed: C79.2, L7.2, U7.26 (SW2)
VCC-3V3-P: C59.2, IC5.38 (VIN_3V3), R132.2; also elsewhere on the board
VCC-CHARG: C67.2, C68.2, C69.1, Q4.6 (D1), Q21.5 (D2), U7.2 (VBUS), U7.3 (VBUS); also elsewhere on the board

Notes on the sheet:
BATTERY CONNECTOR
I Limit = 5 Amp
OPTIONAL
.I2C Address = 0x20 .Min Voltage= 5V .Max Voltage= 20V .Op Current= 1A .Max Current= 5A
Freq=1.5MHz
POWER DELIVERY
BATTERY CHARGER
Put the MCU into RESET mode if use EV2400 to debug the charger
4S/1Amp
NOTE : D+ , D_ are connected to CM4/5
NOTE : SDA,SCL,nINT are connected to MCU
USB-C

Schematic: WATER-PUMP .kicad_sch

Parts:
C105: 150pF/50V; C_0603_1608Metric; VOLTAGERATE 10V; MANUFACTURINGPARTNUMBER *; not fitted
C133: 10uF/25V; C_0603_1608Metric; LCSC C96446
D6: SS34; D_SMA; VOLTAGERATE *; MANUFACTURINGPARTNUMBER *; LCSC C22448055
PUMP1: ZX-ZH1_5-2PWT; Manufacturer Part ZX-ZH1.5-2PWT; LCSC C19272405
Q7: 2302V; Manufacturer Part 2302V; LCSC C7431443
Q8: AO3401; SOT23-3D; VOLTAGERATE *; MANUFACTURINGPARTNUMBER *; LCSC C15127
R25, R81: 10k; R_0603_1608Metric; VOLTAGERATE *; MANUFACTURINGPARTNUMBER *
R43: 100k; R_0603_1608Metric
R47: 20k; R_0603_1608Metric

Connections:
/MCU-STM32/WATER-PUMP-SENSE-ADC: R47.1, R81.2; also elsewhere on the board
/MCU-STM32/WATER-PUMPU-CTRL: Q7.1 (G), R43.1; also elsewhere on the board
GND: C105.1, C133.2, D6.1 (A), PUMP1.2, PUMP1.3, PUMP1.4, Q7.2 (S), R43.2, R47.2; also elsewhere on the board
unnamed: C105.2, C133.1, D6.2 (K), PUMP1.1, Q8.3 (D), R81.1
unnamed: Q7.3 (D), Q8.1 (G), R25.1
VM-5V: Q8.2 (S), R25.2; also elsewhere on the board

Notes on the sheet:
5V MOTOR
WATER PUMP MOTOR CONTROL

Board: 4 copper layers, 349 parts (204 on the bottom side), 288 nets, no tracks yet.
